*****************************************************************
* NXP BUK962R8-60E
*
* Polarity N-Channel
* Ratings 60V/2.800000E-003OHMS/120A
*
* Date Created Thu Jun 28 04:17:42 2012
*
*****************************************************************
* Model Generated by Transim Technology
*           Copyright(c) 2004
*         All Rights Reserved
*    UNPUBLISHED LICENSED SOFTWARE
*           www.transim.com
*
* Contains Proprietary Information Which
* is The Property of Transim or it's licensees.
*
* Commercial Use or Resale Restricted by
* Transim License Agreement.
*
*****************************************************************

.SUBCKT BUK962R8-60E DRAIN GATE SOURCE

LD DRAIN 5 5e-12
RLD2 DRAIN 5 0.0125663706143592
RLD1 5 4 1e-06
LG GATE 1 7.81292696075128e-10
RLG GATE 1 1.96360271543439
LS SOURCE 8 3.20225887222398e-09
RLS2 SOURCE 8 8.04815435829727
RLS1 8 7 0.000267481695870964

RDS 7 4 60000000 TC=-0.005

RS 6 7 0.0001

RD 3 4 0.00161578823076824 TC=0.00568029894165328,1.74340289871322E-05
RBD 9 4 0.00213699279670213 TC=0.00568029894165328,1.74340289871322E-05
DBD 7 9 DBD

M1 3 2 6 6 MINT

RGS 2 6 100000000
CGS 2 6 9.36397683265138e-09
RG 1 2 0.777273761817533

* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    3 2 VALUE { V(13, 0)*I(V11) }
E11    12   0  3 2  1
E12    13   0  TABLE {V(12)}
+ -10	10361
+ -8	10345.5
+ -6	10318.2
+ -5	10293.2
+ -4	10245.6
+ -3	10088.5
+ -2	9374.78
+ -1	5026.06
+ -0.5	2830.41
+ -0.2	1884.98
+ -0.1	1868.71
+ 0	1750.907
+ 0.1	1514.622
+ 0.2	1512.732
+ 0.5	1281.276
+ 1	1051.4978
+ 2	753.6834
+ 3	644.477
+ 4	599.4824
+ 5	574.93
+ 6	559.248
+ 8	538.7142
+ 10	523.9582
+ 12	511.4318
+ 15	494.34
+ 16	488.6234
+ 20	468.1388
+ 25	445.826
+ 30	428.0088
+ 50	388.4034

.MODEL MINT NMOS(Vto=2.15674816598017 Kp=1.094707e+003 Nfs=300000000000 Eta=0
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6 Is=1e-24
+ Js=0 Pb=0.8 Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600 Vmax=1000)

.MODEL DBD D(Bv=66 Ibv=2.500000E-004 Rs=1E-6 Is=2.96294696306376e-12
+ N=1 M=0.62 VJ=0.6 Fc=0.5 Cjo=4.721158e-09 Tt=4.52374e-08)

.ENDS
